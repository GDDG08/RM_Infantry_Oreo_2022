# Keil uVision project Infantry_Oreo.uvprojx, settings and files
target Infantry_Oreo (6160000::V6.16::ARMCLANG)
  device: STM32G473CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry_Oreo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32G473xx,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Core/Inc/Utility;../Core/Inc/SuperCap_Control;../Core/Inc/Peripheral;../Core/Inc/Library;../Core/Inc/Gimbal_Control;../Core/Inc/Const;../Core/Inc/Common_Contrrol;../Core/Inc/Chassis_Control;../Core/Inc/Algorithm;../Drivers/CMSIS/DSP/Include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Application/User/Core
    ../Core/Inc/: configure.h
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c fdcan.c i2c.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Algorithm
    ../Core/Src/Algorithm/: adrc_alg.c ahrs_alg.c crc_alg.c filter_alg.c kalman_alg.c math_alg.c pid_alg.c
  group Chassis_Control
    ../Core/Src/Chassis_Control/: cha_chassis_ctrl.c cha_gimbal_ctrl.c cha_power_ctrl.c cha_referee_ctrl.c
  group Common_Control
    ../Core/Src/Common_Contrrol/: buscomm_cmd.c buscomm_ctrl.c debug_BTlog.c init_ctrl.c watchdog_ctrl.c
  group Const
    ../Core/Src/Const/: const.c infantry3_const.c infantry4_const.c infantry5_const.c infantry6_const.c infantry7_const.c infantry8_const.c
  group Gimbal_Control
    ../Core/Src/Gimbal_Control/: gim_client_ctrl.c gim_gimbal_ctrl.c gim_ins_ctrl.c gim_login_ctrl.c gim_miniPC_ctrl.c gim_remote_ctrl.c gim_shoot_ctrl.c
  group Library
    ../Core/Src/Library/: buff_lib.c font_lib.c gif_lib.c list_lib.c log_lib.c str_lib.c
  group SuperCap_Control
    ../Core/Src/SuperCap_Control/: supercap_ctrl.c
  group Peripheral
    ../Core/Src/Peripheral/: bma2x2_periph.c bmg160_periph.c bmi055_periph.c bmi088_periph.c hi22x_periph.c key_periph.c led_periph.c magnetic_periph.c miniPC_periph.c motor_periph.c oled_periph.c referee_periph.c remote_periph.c sensor_periph.c servo_periph.c
  group Utility
    ../Core/Src/Utility/: adc_util.c dac_util.c fdcan_util.c gpio_util.c i2c_util.c pwm_util.c uart_util.c flash_util.c spi_util.c
software components: CMSIS:CORE 5.5.0
